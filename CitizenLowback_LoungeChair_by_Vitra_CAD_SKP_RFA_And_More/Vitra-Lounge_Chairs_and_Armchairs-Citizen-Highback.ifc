Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-31T15:42:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 31 15:42:59 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{168F6DBC-646E-46EF-B313-6E6F83041A6D}\ifc * Database version: 5507 * Database creation date: Mon Jan 31 15:42:57 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 31 15:42:57 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 31 15:42:57 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Citizen highback, Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback:Citizen highback:423755
In: Level 1
Type - Material: Sand/Avocado, 12 deep black powder-coated (textured)
Type - Dimensions - NominalDepth: 896.563 mm; NominalHeight: 1058.7 mm; NominalLength: 753.492 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Citizen armchair combines an unconventional design with a new way of sitting: the seat is suspended on three cables to enable a pleasant swinging movement, while the backrest is firmly attached to the steel frame.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 27/01/2022
Type - Identity Data - Cost: 0; Description: The Citizen armchair combines an unconventional design with a new way of sitting: the seat is suspended on three cables to enable a pleasant swinging movement, while the backrest is firmly attached to the steel frame.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Citizen highback; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Citizen highback; URL: https://www.vitra.com/en-hu/product/citizen
Type - Materials and Finishes - ChairSecondaryMaterial: 12 deep black powder-coated (textured)
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback; Features: Citizen is available in two versions: Citizen Highback has the typical commanding presence of a lounge chair and offers extraordinary comfort with its high backrest, while Citizen Lowback with a low backrest can be arranged in groups for seating in public lounges and lobbies.; Finish: Citizen is characterised by its tubular steel frame, which defines the structure and shape of the chair, as well as by the freely suspended seat cushion that appears to float above the base.; Grade: n/a; Material: Metal, leather and textile.; ModelNumber: n/a; ModelReference: n/a; Name: Citizen-Highback; ReplacementCost: n/a; Shape: Sculptured; Size: 770x885x1045 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 3.36726 m2; Volume: 0.715209 m3
Materials and Finishes - ChairMainMaterial: Sand/Avocado
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback: Citizen highback; Family and Type: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback: Citizen highback; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback: Citizen highback; Type Id: Vitra-Lounge_Chairs_and_Armchairs-Citizen-Highback: Citizen highback; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
